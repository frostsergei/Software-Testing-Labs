<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32F3_HID_MOUSE_LSM303DLHC.ewp</path>
  </project>
  <batchBuild />
</workspace>
